# Keil uVision project light_temp.uvprojx, settings and files
target Target 1 (5060300::V5.06 update 3 (build 300)::ARMCC)
  device: LPC11C14FBD48/301 NXP
  pack: Keil.LPC1100_DFP.1.4.0
  cpu: IRAM(0x10000000,0x2000) IROM(0x00000000,0x8000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: light_temp
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c include: .\Lib_BSP\inc;.\Lib_MCU\inc
  memory RVCT4: ROM 0x0 size 0x8000
  memory RVCT9: RAM 0x10000000 size 0x2000
  group syetem
    ./Lib_MCU/src/: startup_LPC11xx.s system_LPC11xx.c
    ./Lib_BSP/src/: tools.c
  group main
    ./: main.c devcon.c
  group gpio
    ./Lib_MCU/src/: gpio.c
  group i2c
    ./Lib_MCU/src/: i2c.c
  group light_tmp
    ./Lib_BSP/src/: light.c oled2864.c temp_hum.c
  group ssp
    ./Lib_MCU/src/: ssp.c
  group key
    ./Lib_BSP/src/: key.c
  group acc
    ./Lib_BSP/src/: acc.c
    ./Lib_MCU/src/: adc.c
  group timer32
    ./Lib_MCU/src/: timer32.c
