# Keil uVision project gpio_led.uvprojx, settings and files
target code (5060300::V5.06 update 3 (build 300)::ARMCC)
  device: LPC11C14FBD48/301 NXP
  pack: Keil.LPC1100_DFP.1.4.0
  cpu: IRAM(0x10000000,0x2000) IROM(0x00000000,0x8000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: gpio_led
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c include: .\Lib_MCU\inc;.\Lib_MCU\src;F:\keli_v5\core\ARM\ARMCC\include
  memory RVCT4: ROM 0x0 size 0x8000
  memory RVCT9: RAM 0x10000000 size 0x2000
  link misc: --libpath "F:\keli_v5\core\ARM\ARMCC\lib"
  group system
    ./Lib_MCU/src/: system_LPC11xx.c startup_LPC11xx.s
  group main
    ./: main.c
  group mcu
    ./Lib_MCU/src/: gpio.c
