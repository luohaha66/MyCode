# Keil uVision project oled.uvprojx, settings and files
target Target 1 (5060300::V5.06 update 3 (build 300)::ARMCC)
  device: LPC11C14FBD48/301 NXP
  pack: Keil.LPC1100_DFP.1.4.0
  cpu: IRAM(0x10000000,0x2000) IROM(0x00000000,0x8000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: oled
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c include: .\Lib_BSP\inc;.\Lib_MCU\inc
  memory RVCT4: ROM 0x0 size 0x8000
  memory RVCT9: RAM 0x10000000 size 0x2000
  group system
    ./Lib_MCU/src/: can.c startup_LPC11xx.s system_LPC11xx.c
    ./Lib_BSP/src/: tools.c temp_hum.c
  group main
    ./: main.c
  group gpio
    ./Lib_MCU/src/: gpio.c
  group ssp
    ./Lib_MCU/src/: ssp.c
  group oled
    ./Lib_BSP/src/: oled2864.c
