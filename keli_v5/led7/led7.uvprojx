# Keil uVision project led7.uvprojx, settings and files
target Target 1 (5060300::V5.06 update 3 (build 300)::ARMCC)
  device: LPC11C14FBD48/301 NXP
  pack: Keil.LPC1100_DFP.1.4.0
  cpu: IRAM(0x10000000,0x2000) IROM(0x00000000,0x8000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: led7
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c include: .\Lib_BSP\inc;.\Lib_MCU\inc
  memory RVCT4: ROM 0x0 size 0x8000
  memory RVCT9: RAM 0x10000000 size 0x2000
  group main
    ./: main.c
  group system
    ./Lib_MCU/src/: startup_LPC11xx.s system_LPC11xx.c
  group gpio
    ./Lib_MCU/src/: gpio.c
  group led7
    ./Lib_BSP/src/: led7seg.c seg7led.c
  group ssp
    ./Lib_MCU/src/: ssp.c
